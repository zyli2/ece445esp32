## NimBLE_GATT_Server/build/defconfig
```kconfig
CONFIG_BLINK_LED_STRIP=y
CONFIG_BLINK_GPIO=48
CONFIG_BT_ENABLED=y
CONFIG_BT_NIMBLE_ENABLED=y
# CONFIG_BT_NIMBLE_50_FEATURE_SUPPORT is not set
```
